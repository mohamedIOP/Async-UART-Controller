

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO SYS_TOP 
  PIN SI[3] 
    ANTENNAPARTIALMETALAREA 4.369 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 21.0149 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.958 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.61038 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 48.136 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 238.102 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.3546 LAYER VIA34 ;
  END SI[3]
  PIN SI[2] 
    ANTENNAPARTIALMETALAREA 9.451 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 45.6517 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 181.375 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 869.276 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.677298 LAYER VIA23 ;
  END SI[2]
  PIN SI[1] 
    ANTENNAPARTIALMETALAREA 2.055 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.88455 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.639 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.07599 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 6.828 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 33.0351 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 200.856 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 976.298 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 2.70919 LAYER VIA45 ;
  END SI[1]
  PIN SI[0] 
    ANTENNAPARTIALMETALAREA 1.185 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.69985 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.498 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.39778 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 40.106 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 199.478 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA34 ;
  END SI[0]
  PIN SO[3] 
    ANTENNADIFFAREA 0.537 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 2.198 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.7648 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 47.2161 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 231.871 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.98352 LAYER VIA34 ;
  END SO[3]
  PIN SO[2] 
    ANTENNAPARTIALMETALAREA 2.953 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.2039 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNADIFFAREA 0.6 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 33.305 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 160.389 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 545.849 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 2611.41 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.59972 LAYER VIA56 ;
  END SO[2]
  PIN SO[1] 
    ANTENNAPARTIALMETALAREA 5.079 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 24.43 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.25 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3949 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNADIFFAREA 0.6 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 37.801 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 182.015 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1326 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 365.273 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 1759.3 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 2.21201 LAYER VIA56 ;
  END SO[1]
  PIN SO[0] 
    ANTENNAPARTIALMETALAREA 3.245 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.6085 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 26.121 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 125.834 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0897 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 299.149 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 1444.09 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 2.81717 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 0.268 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.48148 LAYER METAL5 ;
    ANTENNAGATEAREA 0.0897 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 302.137 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 1460.6 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNAMAXCUTCAR 3.62207 LAYER VIA56 ;
    ANTENNAPARTIALMETALAREA 0.6038 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.09235 LAYER METAL6 ;
    ANTENNAGATEAREA 0.0897 LAYER METAL6 ; 
    ANTENNAMAXAREACAR 308.868 LAYER METAL6 ;
    ANTENNAMAXSIDEAREACAR 1483.93 LAYER METAL6 ;
    ANTENNAPARTIALCUTAREA 0.2592 LAYER VIA67 ;
    ANTENNAMAXCUTCAR 6.51171 LAYER VIA67 ;
    ANTENNADIFFAREA 0.6 LAYER METAL7 ; 
    ANTENNAPARTIALMETALAREA 54.876 LAYER METAL7 ;
    ANTENNAPARTIALMETALSIDEAREA 321.961 LAYER METAL7 ;
    ANTENNAGATEAREA 0.2444 LAYER METAL7 ; 
    ANTENNAMAXAREACAR 533.401 LAYER METAL7 ;
    ANTENNAMAXSIDEAREACAR 2801.28 LAYER METAL7 ;
  END SO[0]
  PIN scan_clk 
    ANTENNAPARTIALMETALAREA 0.255 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.22655 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.145 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.88985 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 2.682 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.0928 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 1.48479 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 7.28756 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.0353598 LAYER VIA45 ;
  END scan_clk
  PIN scan_rst 
    ANTENNAPARTIALMETALAREA 3.54 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 17.0274 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.1444 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 5.365 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 26.1905 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.1444 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 6.481 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 31.5584 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1066 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 123.274 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 600.311 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 3.72514 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 2.026 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 9.93746 LAYER METAL5 ;
    ANTENNAGATEAREA 0.1599 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 135.944 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 662.459 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.72514 LAYER VIA56 ;
  END scan_rst
  PIN test_mode 
    ANTENNAPARTIALMETALAREA 4.082 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 19.6344 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.286 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 15.5055 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 73.9336 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAMAXCUTCAR 0.378671 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 5.675 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.4892 LAYER METAL3 ;
    ANTENNAGATEAREA 0.8255 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 22.3801 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 107.234 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.1083 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 1.08875 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 4.508 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 22.0683 LAYER METAL4 ;
    ANTENNAGATEAREA 1.365 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 31.9701 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 153.911 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 1.14165 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 19.866 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 95.7479 LAYER METAL5 ;
    ANTENNAGATEAREA 1.4196 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 58.8842 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 292.721 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 4.62821 LAYER VIA56 ;
  END test_mode
  PIN SE 
    ANTENNAPARTIALMETALAREA 1.995 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.59595 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 5.514 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.0995 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4628 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 26.285 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 128.166 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 1.40406 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 13.442 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 65.0408 LAYER METAL4 ;
    ANTENNAGATEAREA 1.3325 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 67.0634 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 324.349 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 1.55185 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 5.867 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 28.4127 LAYER METAL5 ;
    ANTENNAGATEAREA 1.911 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 70.1335 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 339.217 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.87208 LAYER VIA56 ;
  END SE
  PIN REF_CLK 
    ANTENNAPARTIALMETALAREA 0.141 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.67821 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.384 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.84944 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 0.586914 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 2.90598 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.0235732 LAYER VIA34 ;
  END REF_CLK
  PIN UART_CLK 
    ANTENNAPARTIALMETALAREA 0.241 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.15921 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.206 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.99326 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 1.288 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.38768 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 0.869009 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 4.32568 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.0353598 LAYER VIA45 ;
  END UART_CLK
  PIN RST_N 
    ANTENNAPARTIALMETALAREA 3.367 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 16.1953 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 5.598 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.1188 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 138.63 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 670.566 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA34 ;
  END RST_N
  PIN UART_RX_IN 
    ANTENNAPARTIALMETALAREA 7.475 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 35.9548 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 15.765 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 76.2145 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 277.436 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 1338.61 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 3.08547 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 1.616 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.96536 LAYER METAL4 ;
    ANTENNAGATEAREA 0.1404 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 288.946 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 1395.34 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 3.08547 LAYER VIA45 ;
  END UART_RX_IN
  PIN UART_TX_O 
    ANTENNADIFFAREA 0.401 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 1.693 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.14333 LAYER METAL3 ;
  END UART_TX_O
  PIN parity_error 
    ANTENNADIFFAREA 0.6 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 13.665 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 66.1134 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1937 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 90.1042 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 437.297 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.70919 LAYER VIA34 ;
  END parity_error
  PIN framing_error 
    ANTENNADIFFAREA 0.401 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 1.627 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.82587 LAYER METAL3 ;
  END framing_error
END SYS_TOP

END LIBRARY
